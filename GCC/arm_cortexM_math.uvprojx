# Keil uVision project arm_cortexM_math.uvprojx, settings and files
target cortexM0l (ARM-GNU)
  device: ARMCM0 ARM
  pack: ARM.CMSIS.5.9.0
  cpu: IROM(0x00000000,0x40000) IRAM(0x20000000,0x20000) CPUTYPE("Cortex-M0") CLOCK(12000000) ESEL ELITTLE
  output: arm_cortexM0l_math (library)
  AfterMake: cmd.exe /C copy "$L\lib@L.a" "..\..\Lib\GCC\"
  group BasicMathFunctions
    D:/CMSIS-DSP-1.12.0/Source/BasicMathFunctions/: BasicMathFunctions.c
  group BayesFunctions
    D:/CMSIS-DSP-1.12.0/Source/BayesFunctions/: BayesFunctions.c
  group CommonTables
    D:/CMSIS-DSP-1.12.0/Source/CommonTables/: CommonTables.c
  group ComplexMathFunctions
    D:/CMSIS-DSP-1.12.0/Source/ComplexMathFunctions/: ComplexMathFunctions.c
  group ControllerFunctions
    D:/CMSIS-DSP-1.12.0/Source/ControllerFunctions/: ControllerFunctions.c
  group DistanceFunctions
    D:/CMSIS-DSP-1.12.0/Source/DistanceFunctions/: DistanceFunctions.c
  group FastMathFunctions
    D:/CMSIS-DSP-1.12.0/Source/FastMathFunctions/: FastMathFunctions.c
  group FilteringFunctions
    D:/CMSIS-DSP-1.12.0/Source/FilteringFunctions/: FilteringFunctions.c
  group InterpolationFunctions
    D:/CMSIS-DSP-1.12.0/Source/InterpolationFunctions/: InterpolationFunctions.c
  group MatrixFunctions
    D:/CMSIS-DSP-1.12.0/Source/MatrixFunctions/: MatrixFunctions.c
  group QuaternionFunctions
    D:/CMSIS-DSP-1.12.0/Source/QuaternionMathFunctions/: QuaternionMathFunctions.c
  group StatisticalFunctions
    D:/CMSIS-DSP-1.12.0/Source/StatisticsFunctions/: StatisticsFunctions.c
  group SupportFunctions
    D:/CMSIS-DSP-1.12.0/Source/SupportFunctions/: SupportFunctions.c
  group SVMFunctions
    D:/CMSIS-DSP-1.12.0/Source/SVMFunctions/: SVMFunctions.c
  group TransformFunctions
    D:/CMSIS-DSP-1.12.0/Source/TransformFunctions/: TransformFunctions.c
target cortexM0b (ARM-GNU)
  device: ARMCM0 ARM
  pack: ARM.CMSIS.5.9.0
  cpu: as above
  output: arm_cortexM0b_math (library)
  AfterMake: cmd.exe /C copy "$L\lib@L.a" "..\..\Lib\GCC\"
target cortexM3l (ARM-GNU)
  device: ARMCM3 ARM
  pack: ARM.CMSIS.5.9.0
  cpu: IROM(0x00000000,0x40000) IRAM(0x20000000,0x20000) CPUTYPE("Cortex-M3") CLOCK(12000000) ESEL ELITTLE
  output: arm_cortexM3l_math (library)
  AfterMake: cmd.exe /C copy "$L\lib@L.a" "..\..\Lib\GCC\"
target cortexM3b (ARM-GNU)
  device: ARMCM3 ARM
  pack: ARM.CMSIS.5.9.0
  cpu: as above
  output: arm_cortexM3b_math (library)
  AfterMake: cmd.exe /C copy "$L\lib@L.a" "..\..\Lib\GCC\"
target cortexM4l (ARM-GNU)
  device: ARMCM4 ARM
  pack: ARM.CMSIS.5.9.0
  cpu: IROM(0x00000000,0x80000) IRAM(0x20000000,0x20000) CPUTYPE("Cortex-M4") CLOCK(12000000) ESEL ELITTLE
  output: arm_cortexM4l_math (library)
  AfterMake: cmd.exe /C copy "$L\lib@L.a" "..\..\Lib\GCC\"
target cortexM4b (ARM-GNU)
  device: ARMCM4 ARM
  pack: ARM.CMSIS.5.9.0
  cpu: as above
  output: arm_cortexM4b_math (library)
  AfterMake: cmd.exe /C copy "$L\lib@L.a" "..\..\Lib\GCC\"
target cortexM4lf (ARM-GNU)
  device: ARMCM4_FP ARM
  pack: ARM.CMSIS.5.9.0
  cpu: IROM(0x00000000,0x80000) IRAM(0x20000000,0x20000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ESEL ELITTLE
  output: arm_cortexM4lf_math (library)
  AfterMake: cmd.exe /C copy "$L\lib@L.a" "..\..\Lib\GCC\"
target cortexM4bf (ARM-GNU)
  device: ARMCM4_FP ARM
  pack: ARM.CMSIS.5.9.0
  cpu: as above
  output: arm_cortexM4bf_math (library)
  AfterMake: cmd.exe /C copy "$L\lib@L.a" "..\..\Lib\GCC\"
target cortexM7l (ARM-GNU)
  device: ARMCM7 ARM
  pack: ARM.CMSIS.5.9.0
  cpu: IROM(0x00000000,0x80000) IRAM(0x20000000,0x20000) CPUTYPE("Cortex-M7") CLOCK(12000000) ESEL ELITTLE
  output: arm_cortexM7l_math (library)
  AfterMake: cmd.exe /C copy "$L\lib@L.a" "..\..\Lib\GCC\"
target cortexM7b (ARM-GNU)
  device: ARMCM7 ARM
  pack: ARM.CMSIS.5.9.0
  cpu: as above
  output: arm_cortexM7b_math (library)
  AfterMake: cmd.exe /C copy "$L\lib@L.a" "..\..\Lib\GCC\"
target cortexM7lfsp (ARM-GNU)
  device: ARMCM7_SP ARM
  pack: ARM.CMSIS.5.9.0
  cpu: IROM(0x00000000,0x80000) IRAM(0x20000000,0x20000) CPUTYPE("Cortex-M7") FPU3(SFPU) CLOCK(12000000) ESEL ELITTLE
  output: arm_cortexM7lfsp_math (library)
  AfterMake: cmd.exe /C copy "$L\lib@L.a" "..\..\Lib\GCC\"
target cortexM7bfsp (ARM-GNU)
  device: ARMCM7_SP ARM
  pack: ARM.CMSIS.5.9.0
  cpu: as above
  output: arm_cortexM7bfsp_math (library)
  AfterMake: cmd.exe /C copy "$L\lib@L.a" "..\..\Lib\GCC\"
target cortexM7lfdp (ARM-GNU)
  device: ARMCM7_DP ARM
  pack: ARM.CMSIS.5.9.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ESEL ELITTLE
  output: arm_cortexM7lfdp_math (library)
  AfterMake: cmd.exe /C copy "$L\lib@L.a" "..\..\Lib\GCC\"
target cortexM7bfdp (ARM-GNU)
  device: ARMCM7_DP ARM
  pack: ARM.CMSIS.5.9.0
  cpu: IROM(0x00000000,0x80000) IRAM(0x20000000,0x20000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ESEL ELITTLE
  output: arm_cortexM7bfdp_math (library)
  AfterMake: cmd.exe /C copy "$L\lib@L.a" "..\..\Lib\GCC\"
target ARMv8MBLl (ARM-GNU)
  device: ARMv8MBL ARM
  pack: ARM.CMSIS.5.9.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x20200000,0x00020000) IROM(0x00000000,0x00200000) IROM2(0x00200000,0x00200000) CPUTYPE("ARMV8MBL") TZ CLOCK(12000000) ESEL ELITTLE
  output: arm_ARMv8MBLl_math (library)
  AfterMake: cmd.exe /C copy "$L\lib@L.a" "..\..\Lib\GCC\"
target ARMv8MMLl (ARM-GNU)
  device: ARMv8MML ARM
  pack: ARM.CMSIS.5.9.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x20200000,0x00020000) IROM(0x00000000,0x00200000) IROM2(0x00200000,0x00200000) CPUTYPE("ARMV8MML") TZ CLOCK(12000000) ESEL ELITTLE
  output: arm_ARMv8MMLl_math (library)
  AfterMake: cmd.exe /C copy "$L\lib@L.a" "..\..\Lib\GCC\"
target ARMv8MMLlfsp (ARM-GNU)
  device: ARMv8MML_SP ARM
  pack: ARM.CMSIS.5.9.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x20200000,0x00020000) IROM(0x00000000,0x00200000) IROM2(0x00200000,0x00200000) CPUTYPE("ARMV8MML") FPU3(SFPU) TZ CLOCK(12000000) ESEL ELITTLE
  output: arm_ARMv8MMLlfsp_math (library)
  AfterMake: cmd.exe /C copy "$L\lib@L.a" "..\..\Lib\GCC\"
target ARMv8MMLlfdp (ARM-GNU)
  device: ARMv8MML_DP ARM
  pack: ARM.CMSIS.5.9.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x20200000,0x00020000) IROM(0x00000000,0x00200000) IROM2(0x00200000,0x00200000) CPUTYPE("ARMV8MML") FPU3(DFPU) TZ CLOCK(12000000) ESEL ELITTLE
  output: arm_ARMv8MMLlfdp_math (library)
  AfterMake: cmd.exe /C copy "$L\lib@L.a" "..\..\Lib\GCC\"
target ARMv8MMLld (ARM-GNU)
  device: ARMv8MML_DSP ARM
  pack: ARM.CMSIS.5.9.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x20200000,0x00020000) IROM(0x00000000,0x00200000) IROM2(0x00200000,0x00200000) CPUTYPE("ARMV8MML") DSP TZ CLOCK(12000000) ESEL ELITTLE
  output: arm_ARMv8MMLld_math (library)
  AfterMake: cmd.exe /C copy "$L\lib@L.a" "..\..\Lib\GCC\"
target ARMv8MMLldfsp (ARM-GNU)
  device: ARMv8MML_DSP_SP ARM
  pack: ARM.CMSIS.5.9.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x20200000,0x00020000) IROM(0x00000000,0x00200000) IROM2(0x00200000,0x00200000) CPUTYPE("ARMV8MML") FPU3(SFPU) DSP TZ CLOCK(12000000) ESEL ELITTLE
  output: arm_ARMv8MMLldfsp_math (library)
  AfterMake: cmd.exe /C copy "$L\lib@L.a" "..\..\Lib\GCC\"
target ARMv8MMLldfdp (ARM-GNU)
  device: ARMv8MML_DSP_DP ARM
  pack: ARM.CMSIS.5.9.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x20200000,0x00020000) IROM(0x00000000,0x00200000) IROM2(0x00200000,0x00200000) CPUTYPE("ARMV8MML") FPU3(DFPU) DSP TZ CLOCK(12000000) ESEL ELITTLE
  output: arm_ARMv8MMLldfdp_math (library)
  AfterMake: cmd.exe /C copy "$L\lib@L.a" "..\..\Lib\GCC\"
